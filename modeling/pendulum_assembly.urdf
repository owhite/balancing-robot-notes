Commit message: oct11_LQR_modeling.md

File: modeling/pendulum_assembly.urdf (robot description, URDF)
Before this commit: robot pendulum_assembly, 2 links, 1 joints
Joints:
- joint pendulum_joint: origin xyz=0.0 0.0 0.045138 rpy=0 0 0 -> xyz=0.000000 0.000000 0.045138 rpy=0 0 0
